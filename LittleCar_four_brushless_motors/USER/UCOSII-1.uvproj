# Keil uVision project UCOSII-1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UCOSII-1 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99 --no_strict --gnu
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HAL;..\MAVLink;..\MAVLink\common;..\APP;..\STM32_CPAL_Driver\inc;..\STM32_CPAL_Driver\devices\stm32f10x;..\STM32_CPAL_Driver;..\USART2;..\SYSTEM\usart;..\UCOSII\CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: zhp_app.c zhp_app.h zhp_control_app.c zhp_control_app.h zhp_crc.c zhp_crc.h zhp_frame.h zhp_frame.c zhp_ext_int.c zhp_ext_int.h
  group USER
    ./: main.c config.c config.h system_stm32f10x.c stm32f10x_it.c
  group HAL
    ../HAL/: IMU.c IMU.h HMC5883L.c HMC5883L.h MPU6050.c MPU6050.h MS5611.h MS5611.c DMA.c DMA.h IOI2C.c IOI2C.h LED.c LED.h eeprom.h eeprom.c timer.c timer.h Motors.c Motors.h pstwo.h pstwo.c wdg.c wdg.h
    ../USART2/: usart2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_crc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
